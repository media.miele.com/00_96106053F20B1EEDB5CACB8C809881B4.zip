Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-04-04T09:36:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 04 09:36:14 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\a7ee306b-85f9-4597-aa38-a8e6f9e51c46\159bc82f-b3f1-4163-b4bf-6fa278a07565\ifc * Database version: 5507 * Database creation date: Tue Apr 04 09:36:12 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 04 09:36:12 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 04 09:36:12 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12260590_NWE_PDR511ROPHP_IG-IG:52511001_NWE_12260590_PDR511ROPHP_IG-IG, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 52511001_NWE_12260590_PDR511ROPHP_IG-IG
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 52511001_NWE_12260590_PDR511ROPHP_IG-IG
Material: z_Miele_Design_CLST, z_Miele_Connection_Gas, z_Miele_Design_OBSW, z_Miele_Design_Glass, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Connection_Water_IN, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - sets with these values: 2
